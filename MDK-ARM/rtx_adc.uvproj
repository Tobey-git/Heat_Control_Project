# Keil uVision project rtx_adc.uvproj, settings and files
target rtx_adc (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: rtx_adc
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --C99
  c include: ../Inc;                    ../Drivers/STM32F1xx_HAL_Driver/Inc;                    ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;                    ../Drivers/CMSIS/Include;                    ../Drivers/CMSIS/Device/ST/STM32F1xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: stm32f1xx_it.c usart.c spi.c main.c stm32f1xx_hal_msp.c gpio.c tim.c RTX_Conf.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_pwr.c
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group BSP
    ../Src/: ADS1248.c step_motor_driver.c pid_driver.c
    ../Inc/: ADS1248.h
